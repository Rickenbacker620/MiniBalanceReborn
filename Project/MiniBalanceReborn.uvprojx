# Keil uVision project MiniBalanceReborn.uvprojx, settings and files
target MiniBalanceReborn (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MiniBalanceReborn
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\CMSIS;..\FWLIB\inc;..\HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DMP;..\HARDWARE\IIC;..\HARDWARE\ENCODER;..\HARDWARE\OLED;..\MiniBalance\show;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\MOTOR;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\MiniBalance\DataScope_DP;..\MiniBalance\filter;..\HARDWARE\STMFLASH;..\HARDWARE\USARTX;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\CAN;..\HARDWARE\PS2;..\HARDWARE\MPU9250;..\HARDWARE\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s
  group MiniBalance
    ../MiniBalance/CONTROL/: control.c
    ../MiniBalance/DataScope_DP/: DataScope_DP.C
    ../MiniBalance/filter/: filter.c
    ../MiniBalance/show/: show.c
  group HARDWARE
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
